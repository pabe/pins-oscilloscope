# Keil uVision project oscilloscope.uvproj, settings and files
target STM32F107VC (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: oscilloscope +hex
  c flags: Optim=4 wLevel=2
  c include: .;Firmware;Firmware\inc;FreeRTOS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Firmware
    ./Firmware/: STM32F10x.s system_stm32f10x_cl.c stm3210c_eval_ioe.c GLCD.c
    ./Firmware/src/: stm32f10x_gpio.c stm32f10x_exti.c misc.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_rcc.c
  group Application
    ./Firmware/: setup.c
    ./: main.c config.h task_input_gpio.c task_watchdog.c api_controller.c api_watchdog.c task_controller.c api.c api_input_touch.c task_input_touch.c task_display.c api_display.c task_measure.c
  group FreeRTOS
    ./FreeRTOS/src/: heap_2.c list.c port.c queue.c tasks.c
