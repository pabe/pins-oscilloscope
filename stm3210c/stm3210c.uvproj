# Keil uVision project stm3210c.uvproj, settings and files
target pins-oscilloscope (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: stm3210c
  c flags: Optim=1
  c include: .;Firmware;Firmware\inc;FreeRTOS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Firmware
    ./Firmware/: STM32F10x.s system_stm32f10x_cl.c GLCD.c
  group Application
    ./: main.c
    ./Firmware/: setup.c
  group FreeRTOS
    ./FreeRTOS/src/: heap_2.c list.c port.c queue.c tasks.c
